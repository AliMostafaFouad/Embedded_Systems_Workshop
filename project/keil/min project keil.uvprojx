# Keil uVision project min project keil.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: min project keil +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./Mini project/: EXTI_program.c AFIO_program.c GPIO_program.c main.c NVIC_Program.c RCC_program.c SCB_program.c STK_program.c timer_program.c timer_private.h timer_interface.h timer_config.h STK_private.h STK_interface.h STK_config.h STD_TYPES.h SCB_private.h SCB_interface.h SCB_config.h RCC_private.h RCC_interface.h RCC_config.h NVIC_Private.h NVIC_Interface.h NVIC_Config.h GPIO_private.h GPIO_interface.h GPIO_config.h EXTI_private.h EXTI_interface.h EXTI_config.h BIT_MATH.h AFIO_private.h AFIO_interface.h AFIO_config.h
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0
